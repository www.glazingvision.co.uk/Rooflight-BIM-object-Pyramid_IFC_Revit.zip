Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-01-25T15:57:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Jan 25 15:57:46 2017* Host: NCL-PI08* Database: C:\Users\KovacsG\AppData\Local\Temp\{9733C45A-565C-4F74-8805-3BFFEA821522}\ifc* Database version: 5507* Database creation date: Wed Jan 25 15:57:45 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Jan 25 15:57:45 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Jan 25 15:57:45 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: X:\NBL\Manufacturer\G\Glazing Vision_12688\NBLA0680\Authoring\IFC\NBS_GlazingVisionLtd_FrmdRflghts_PyramidStandard.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcWindow: DoubleGlazed-1200x1200mm_6-20-6mm, NBS_GlazingVisionLtd_FrmdRflghts_PyramidStandard:DoubleGlazed-1200x1200mm_6-20-6mm:187437
In: Level 1
Type - ConstructionType: OTHER_CONSTRUCTION; ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_30_59_72_31 (Uniclass2015); Material: NBS_Glass_Double, NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_GlazingVisionLtd_FramedRooflights_PyramidStandard_DoubleGlazed; ManufacturerName: Glazing Vision Ltd; ManufacturerURL: www.glazingvision.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/rzaeauvg; NBSDescription: Framed rooflights; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-99/410; NBSTypeID: n/a; ProductInformation: www.glazingvision.co.uk/rooflights/pyramid-rooflights/fixed-pyramid-rooflight/; Revision: n/a; Uniclass2015Code: Pr_30_59_72_31; Uniclass2015Title: Framed rooflights; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - Accessories: Clearshield glass coating, low voltage down light, trickle ventilation; CavityType: 20 mm black silicone sealed warm edge argon filled; Certification: n/a; Form: Square pyramid; FrameFinishCoating: Qualicoat approved polyester powder coating; FrameFinishColour: RAL 7015 Grey (Outer), RAL 9010 White (Inner); FrameFinishTexture: n/a; FrameMaterial: Aluminium; GlazingAngle: 45° from horizontal; GlazingOptions: Double, triple; GlazingOrInfillCoating: Low-e coating; GlazingOrInfillConstruction: Double glazed; GlazingOrInfillType: Insulated glass units; InnerPaneType: 6 mm heat soak tested soft low e toughened; IntermediatePaneType: n/a; LightTransmission: 0.77; MaximumArea: 2.25 m²; MaximumSize: 1500 mm; MinimumSize: 600 mm; OperationControl: n/a; OperationType: Fixed; OuterPaneType: 6 mm heat soak tested toughened; PitchAngleRange: 0-10°; RooflightWeight: 89 kg (1200 x 1200 mm); Seals: Silicone and butyl; ShadingCoefficient: 0; StructuralKerb: To builders kerb (by others) min 100 mm wide, 150 mm high; ThermalBreak: yes; WholeWindowUValue: 3.6 W/m²K Uw
Type - Pset_WindowCommon - AcousticRating: 31 db; FireRating: n/a; GlazingAreaFraction: 0; Infiltration: 0; IsExternal: yes; Reference: n/a; SecurityRating: n/a; SmokeStop: no; ThermalTransmittance: 0
Type - Pset_DoorWindowGlazingType - BeamRadiationTransmittance: 0; FillGas: Argon; GlassColor: Clear; GlassLayers: 2; GlassThickness1: 6 mm; GlassThickness2: 6 mm; GlassThickness3: 0 mm; IsCoated: yes; IsLaminated: no; IsTempered: yes; IsWired: no; Reflectivity: 0; SolarHeatGainTransmittance: 0; ThermalTransmittanceSummer: 0; ThermalTransmittanceWinter: 0; Translucency: 0
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_72_31: Framed rooflights; CodePerformance: n/a; Color: Grey/white frame, clear glass; Constituents: Aluminium, double IGU; Description: Double glazed pyramid style rooflight for daylight applications, optional built in internal light at apex, glass to glass joints; DurationUnit: year; ExpectedLife: n/a; Features: Glass to glass silicone joints, internal downlight, thermally broken framework, dual colour as standard; Finish: n/a; Grade: n/a; Manufacturer: sales@glazingvision.co.uk; Material: Aluminium, glass; ModelNumber: 404; ModelReference: GV Standard Pyramid Double Glazed Rooflight; Name: FramedRooflights_PyramidStandard_DoubleGlazed_GlazingVisionLtd; NominalHeight: 0 mm; NominalLength: 1200 mm; NominalWidth: 1200 mm; ReplacementCost: n/a; Shape: Square pyramid; Size: 1200 x 1200 mm; SustainabilityPerformance: n/a; WarrantyDescription: Manufacturer's warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2 (installed by others) or 10 years (installed by Glazing Vision); WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: customerservices@glazingvision.co.uk
OverallHeight: 916.134 mm; OverallWidth: 1500 mm
NBS_Data - ComponentNumber: n/a; WindowNumber: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
